# Keil uVision project RemoteControl2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RemoteControl2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\STC_LIB;.\APP
  group APP
    ./APP/: config.c bsp.c devices.c main.c wifi.c sys.c http_ap.c
  group STC_LIB
    ./STC_LIB/: GPIO.c PCA.c USART.C
