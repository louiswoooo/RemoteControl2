# Keil uVision project RemoteControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RemoteControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\stc_lib
  group Source Group 1
    ./source/: main.c bsp.c timer_config.c wifi.c devices.c
  group stc_lib
    ./stc_lib/: delay.c GPIO.c USART.C PCA.c
